# Keil uVision project test.uvprojx, settings and files
target UART (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyFirstJob
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group boot
    ./boot/: cortexm3_macro.s stm32f10x_vector.s
  group library
    ./library/src/: stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_systick.c
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group src
    ./src/: main.c init.c
  group stm32_dsp
    ./src/: stm32_dsp.h table_fft.h cr4_fft_1024_stm32.s
